# Keil uVision project MeteoStation.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MeteoStation
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c fonts.c oled.c oled.h i2c.h i2c.c bme280.h bme280.c ds3231.c ds3231.h adc.c adc.h sys_data.h sys_data.c tim2.c tim2.h scheduler.c scheduler.h tasks.c tasks.h zambretti.c zambretti.h history.c history.h ultraviolet.c ultraviolet.h delay.c delay.h fonts.h tim3.c tim3.h apptemp.c apptemp.h anemo.c anemo.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
